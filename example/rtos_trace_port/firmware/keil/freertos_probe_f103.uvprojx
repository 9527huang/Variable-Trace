# Keil uVision project freertos_probe_f103.uvprojx, settings and files
target freertos_probe_f103 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: freertos_probe_f103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: PROBE_CPU_HZ=8000000,PROBE_HEAP_KB=14
  c include: ..;../../../../third_party/FreeRTOS-Kernel/include;../../../../third_party/FreeRTOS-Kernel/portable/GCC/ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f103xb.s
  group User
    ../: main.c
  group FreeRTOS
    ../../../../third_party/FreeRTOS-Kernel/: tasks.c list.c queue.c
    ../../../../third_party/FreeRTOS-Kernel/portable/GCC/ARM_CM3/: port.c
    ../../../../third_party/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.5.0
